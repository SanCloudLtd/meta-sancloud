FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-arm-dts-Update-SanCloud-DTS-files.patch"
