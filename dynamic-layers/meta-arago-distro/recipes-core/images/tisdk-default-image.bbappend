# Copyright (C) 2020-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

IMAGE_INSTALL += "packagegroup-base"
