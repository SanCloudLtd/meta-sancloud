BRANCH = "linux-sancloud-rt-5.4.y"
SRCREV = "514250a0a7dc10f0eae4ae7b3b918125b57794d8"
PV = "5.4.43+git${SRCPV}"

require linux-bbe-5.4.inc
