# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "2cc2e04c45ed9e52c2216e0b29fc57c6f7ff2e08"
require linux-bbe-5.10.inc
