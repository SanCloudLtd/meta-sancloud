# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "6b2dc263914440c027042fc684828883c23b9a64"
KBUILD_DEFCONFIG = "sancloud_rt_defconfig"
require linux-bbe-5.10.inc
