# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "43ba8ad1df9df3dc4b75676a94d2efb3ee9bc7a1"
require linux-bbe-5.10.inc
