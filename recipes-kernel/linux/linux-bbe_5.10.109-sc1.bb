# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "e7a54d11fca07c0878f42a090aed75f4e4242c9d"
require linux-bbe-5.10.inc
