BRANCH = "linux-sancloud-rt-4.19.y"
SRCREV = "7d93d7fbb7c96ac8ad0620bc68f2a9311b5fb593"
PV = "4.19.31+git${SRCPV}"

require linux-bbe-4.19.inc
