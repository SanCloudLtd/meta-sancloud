# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "bf945fc867067627b75852148cfd5da879c85746"
KBUILD_DEFCONFIG = "sancloud_rt_defconfig"
require linux-bbe-5.10.inc
