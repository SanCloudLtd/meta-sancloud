# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "db2b588a350388b39a0fb1d6e6ceab5b58256217"
KBUILD_DEFCONFIG = "sancloud_rt_defconfig"
require linux-bbe-5.10.inc
