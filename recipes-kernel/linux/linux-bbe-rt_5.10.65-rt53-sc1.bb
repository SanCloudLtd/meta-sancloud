# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "6399d0b5951dbc59332f9f70d3eeb022ca3b386d"
require linux-bbe-5.10.inc
