# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "b91a0549c93fcfed83dbd942880559e169e59206"
require linux-bbe-5.10.inc
