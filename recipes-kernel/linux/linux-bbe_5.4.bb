BRANCH = "linux-sancloud-5.4.y"
SRCREV = "aa7f8f7fec8744ade6af31fbb45ba807559ae47c"
PV = "5.4.40+git${SRCPV}"

require linux-bbe-5.4.inc
