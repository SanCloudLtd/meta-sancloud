# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "859ee6556711694262751de2a91acca7800231ff"
require linux-bbe-5.10.inc
