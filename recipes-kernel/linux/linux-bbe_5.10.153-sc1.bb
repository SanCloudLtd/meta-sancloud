# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "23ada84e20dec82946a4cd7a104061982b77c7ed"
require linux-bbe-5.10.inc
