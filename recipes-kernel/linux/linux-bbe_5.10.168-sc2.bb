# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "2c27745a9ebe5d79d31a22d36665e5af73808147"
require linux-bbe-5.10.inc
