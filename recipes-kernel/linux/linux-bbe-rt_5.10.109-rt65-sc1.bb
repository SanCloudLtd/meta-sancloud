# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "32412cccd3595ce635bfe961b6876b9c70ad6918"
KBUILD_DEFCONFIG = "sancloud_rt_defconfig"
require linux-bbe-5.10.inc
