# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "20e637fc6f2f64f5b38af9b28eb9d4daa704e1c6"
require linux-bbe-5.10.inc
