# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "005f1bd5a0a3b17e920b1ccb28a3355aaf6d934b"
require linux-bbe-5.10.inc
