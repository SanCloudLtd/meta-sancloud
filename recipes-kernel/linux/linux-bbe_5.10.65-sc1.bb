# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "8f35e1b0a349aa95c39064021b65254c7e8d489f"
require linux-bbe-5.10.inc
