# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

BRANCH = "linux-sancloud-rt-5.10.y"
SRCREV = "d9ed4116af5fd8337465d83cc0b2426cdf767b9b"
KBUILD_DEFCONFIG = "sancloud_rt_defconfig"
require linux-bbe-5.10.inc
