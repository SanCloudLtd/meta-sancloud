# Copyright (C) 2018-2022 SanCloud Ltd
# SPDX-License-Identifier: MIT

SRCREV = "cbf5fd3afbe32ebde7f42da33ab9254c380a6ac5"
require linux-bbe-5.10.inc
